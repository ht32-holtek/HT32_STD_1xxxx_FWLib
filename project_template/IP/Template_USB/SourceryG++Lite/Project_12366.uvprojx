# Keil uVision project Project_12366.uvprojx, settings and files
target HT32 (ARM-GNU)
  device: HT32F12366 Holtek
  pack: Holtek.HT32_DFP.1.0.63
  cpu: IROM(0x00000000-0x0003FBFF) IRAM(0x20000000-0x2001FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HT32 +hex
  AfterMake: arm-none-eabi-objcopy.exe -O binary "!L.elf" "!L.bin"
  AfterMake: arm-none-eabi-size.exe "!L.elf"
  group User
    ../: main.c ht32f1xxxx_01_it.c ht32_usbd_class.c ht32_usbd_descriptor.c
  group Config
    ../: _ht32_project_source.h ht32_board_config.h ht32f1xxxx_conf.h ht32f1xxxx_01_usbdconf.h
    ./: HT32F1xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f1xxxx_02.c
  group Sourcery G++Lite
    ./: startup_ht32f1xxxx_cs3_01.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F1xxxx_Driver/src/: ht32_cm3_misc.c ht32f1xxxx_adc.c ht32f1xxxx_aes.c ht32f1xxxx_bftm.c ht32f1xxxx_ckcu.c ht32f1xxxx_cmp.c ht32f1xxxx_crc.c ht32f1xxxx_ebi.c ht32f1xxxx_exti.c ht32f1xxxx_flash.c ht32f1xxxx_gpio.c ht32f1xxxx_i2c.c ht32f1xxxx_i2s.c ht32f1xxxx_mctm.c ht32f1xxxx_pdma.c ht32f1xxxx_pwrcu.c ht32f1xxxx_rstcu.c ht32f1xxxx_rtc.c ht32f1xxxx_sci.c ht32f1xxxx_sdio.c ht32f1xxxx_spi.c ht32f1xxxx_tm.c ht32f1xxxx_usart.c ht32f1xxxx_usbd.c ht32f1xxxx_wdt.c ht32f2xxxx_csif.c
  group Retarget
    ../../../../library/HT32F1xxxx_Driver/src/: ht32_retarget.c ht32_serial.c printf.c syscalls.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
  group Doc
    ../: readme.txt
